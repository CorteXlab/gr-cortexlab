<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>ieee802_15_4_tx_picosdr</value></param>
<param><key>title</key><value>TX IEEE 802.15.4 PicoSDR</value></param>
<param><key>author</key><value>Abdelbasset MASSOURI</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>8e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>freq</value></param>
<param><key>value</key><value>860e6</value></param>
</block>
<block>
<key>nutaq_radio420_rx</key>
<param><key>id</key><value>nutaq_radio420_rx_0_0</value></param>
<param><key>target_id</key><value>nutaq_carrier_perseus_0</value></param>
<param><key>selected_card</key><value>2</value></param>
<param><key>enable</key><value>0</value></param>
<param><key>reference</key><value>1</value></param>
<param><key>rx_freq</key><value>freq</value></param>
<param><key>datarate</key><value>samp_rate*2</value></param>
<param><key>calibrate</key><value>1</value></param>
<param><key>band</key><value>0</value></param>
<param><key>update_rate</key><value>1</value></param>
<param><key>rx_lna_gain</key><value>2</value></param>
<param><key>rx_vga1_gain</key><value>1</value></param>
<param><key>rx_gain2</key><value>0</value></param>
<param><key>rx_gain3</key><value>-8</value></param>
<param><key>rx_lpf_bandwidth</key><value>6</value></param>
<param><key>rx_rf_filter</key><value>2</value></param>
</block>
<block>
<key>nutaq_radio420_tx</key>
<param><key>id</key><value>nutaq_radio420_tx_0_0_0</value></param>
<param><key>target_id</key><value>nutaq_carrier_perseus_0</value></param>
<param><key>selected_card</key><value>2</value></param>
<param><key>enable</key><value>0</value></param>
<param><key>reference</key><value>1</value></param>
<param><key>tx_freq</key><value>freq</value></param>
<param><key>datarate</key><value>samp_rate*2</value></param>
<param><key>calibrate</key><value>1</value></param>
<param><key>band</key><value>0</value></param>
<param><key>update_rate</key><value>1</value></param>
<param><key>tx_vga1_gain</key><value>-17</value></param>
<param><key>tx_vga2_gain</key><value>5</value></param>
<param><key>tx_gain3</key><value>-4</value></param>
<param><key>tx_lpf_bandwidth</key><value>6</value></param>
</block>
<block>
<key>nutaq_radio420_rx</key>
<param><key>id</key><value>nutaq_radio420_rx_0_1</value></param>
<param><key>target_id</key><value>nutaq_carrier_perseus_0</value></param>
<param><key>selected_card</key><value>1</value></param>
<param><key>enable</key><value>0</value></param>
<param><key>reference</key><value>0</value></param>
<param><key>rx_freq</key><value>freq</value></param>
<param><key>datarate</key><value>samp_rate*2</value></param>
<param><key>calibrate</key><value>1</value></param>
<param><key>band</key><value>0</value></param>
<param><key>update_rate</key><value>1</value></param>
<param><key>rx_lna_gain</key><value>2</value></param>
<param><key>rx_vga1_gain</key><value>1</value></param>
<param><key>rx_gain2</key><value>0</value></param>
<param><key>rx_gain3</key><value>-8</value></param>
<param><key>rx_lpf_bandwidth</key><value>6</value></param>
<param><key>rx_rf_filter</key><value>2</value></param>
</block>
<block>
<key>nutaq_custom_register</key>
<param><key>id</key><value>nutaq_custom_register_0_1</value></param>
<param><key>target_id</key><value>nutaq_carrier_perseus_0</value></param>
<param><key>index</key><value>1</value></param>
<param><key>value</key><value>6</value></param>
<param><key>update_rate</key><value>1</value></param>
</block>
<block>
<key>nutaq_custom_register</key>
<param><key>id</key><value>nutaq_custom_register_0_0</value></param>
<param><key>target_id</key><value>nutaq_carrier_perseus_0</value></param>
<param><key>index</key><value>4</value></param>
<param><key>value</key><value>0</value></param>
<param><key>update_rate</key><value>1</value></param>
</block>
<block>
<key>nutaq_carrier_perseus</key>
<param><key>id</key><value>nutaq_carrier_perseus_0</value></param>
<param><key>ip_addr</key><value>192.168.1.101</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>taps</value></param>
<param><key>label</key><value>Taps</value></param>
<param><key>value</key><value>[0, sin(pi/8), sin(pi/4), sin(3*pi/8), 1, sin(5*pi/8), sin(3*pi/4), sin(7*pi/8)]</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>interpolation</value></param>
<param><key>label</key><value>Interpolation</value></param>
<param><key>value</key><value>8</value></param>
</block>
<block>
<key>nutaq_radio420_tx</key>
<param><key>id</key><value>nutaq_radio420_tx_0_0</value></param>
<param><key>target_id</key><value>nutaq_carrier_perseus_0</value></param>
<param><key>selected_card</key><value>1</value></param>
<param><key>enable</key><value>1</value></param>
<param><key>reference</key><value>0</value></param>
<param><key>tx_freq</key><value>freq</value></param>
<param><key>datarate</key><value>samp_rate*2</value></param>
<param><key>calibrate</key><value>1</value></param>
<param><key>band</key><value>0</value></param>
<param><key>update_rate</key><value>1</value></param>
<param><key>tx_vga1_gain</key><value>-10</value></param>
<param><key>tx_vga2_gain</key><value>15</value></param>
<param><key>tx_gain3</key><value>3</value></param>
<param><key>tx_lpf_bandwidth</key><value>9</value></param>
</block>
<block>
<key>nutaq_rtdex_sink</key>
<param><key>id</key><value>nutaq_rtdex_sink_0_0</value></param>
<param><key>target_id</key><value>nutaq_carrier_perseus_0</value></param>
<param><key>type</key><value>short</value></param>
<param><key>media_type</key><value>0</value></param>
<param><key>packet_size</key><value>8192/32</value></param>
<param><key>num_chan</key><value>1</value></param>
<param><key>channels</key><value>1</value></param>
</block>
<block>
<key>lms6002d_dac_mux</key>
<param><key>id</key><value>lms6002d_dac_mux_0</value></param>
</block>
<block>
<key>ieee802_15_4_transmitter</key>
<param><key>id</key><value>ieee802_15_4_transmitter_0</value></param>
<param><key>interpolation</key><value>4</value></param>
<param><key>taps</key><value>[0, sin(pi/4), 1, sin(3*pi/4)]</value></param>
</block>
<connection><source_block_id>ieee802_15_4_transmitter_0</source_block_id><sink_block_id>lms6002d_dac_mux_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lms6002d_dac_mux_0</source_block_id><sink_block_id>nutaq_rtdex_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
